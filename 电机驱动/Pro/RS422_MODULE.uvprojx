# Keil uVision project RS422_MODULE.uvprojx, settings and files
target RESS_MODULE (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: RS422_MODULE +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\USER\INC;..\..\uCOSII\CORE;..\..\uCOSII\PORT;..\..\uCOSII\CONFIG;..\..\Libraries\Startup;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\GeneralFunction\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../../USER/SRC/: main.c beep.c action.c can1.c can2.c cancontrolist.c delay.c ili9320.c ili9320_api.c lcd.c key.c led.c led8.c math.c motor.c param.c pid.c queue.c stm32f4xx_it.c tim.c usart1.c usart2.c
  group STM32_LIB
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c
    ../../USER/INC/: stm32f4xx_it.h
  group MDK_STARTUP
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../USER/SRC/: system_stm32f10x.c
  group uC/OS-ⅡCORE
    ../../uCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uC/OS-ⅡPORT
    ../../uCOSII/PORT/: os_cpu_c.c os_dbg.c
