# Keil uVision project 模板.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F405VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\Startup;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User\inc;..\uCOSII\PORT;..\uCOSII\CORE;..\uCOSII\CONFIG;..\GeneralFunction\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/SRC/: main.c pid.c can2.c tim2.c usart1.c can1.c param.c tim5.c filter.c tim3.c usart2.c usart3.c
    ../USER/INC/: macro.h
  group MOTORLIB
    ../USER/SRC/: dianji.c elmo.c vesc.c canctrollist.c queue.c odrive.c akmotor.c
  group INDEXLIB
    ../USER/SRC/: cylinder.c DataScope_DP.C delay.c led.c led8.c utils.c numchange.c
  group LIB
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_fsmc.c stm32f4xx_flash.c stm32f4xx_syscfg.c
    ../User/src/: stm32f4xx_it.c
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f4xx.c
  group STARTUP
    ../Libraries/Startup/: startup_stm32f4xx.s
  group UCOS_PORT
    ../uCOSII/PORT/: os_cpu_c.c os_dbg.c os_cpu.h os_cpu_a.asm
  group UCOS_CORE
    ../uCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group UCOS_CONFIG
    ../uCOSII/CONFIG/: includes.h os_cfg.h
software components: CMSIS:CORE 3.40.0, Device:Startup 2.6.2
