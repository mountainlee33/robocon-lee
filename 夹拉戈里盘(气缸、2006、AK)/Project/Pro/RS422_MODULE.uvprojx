# Keil uVision project RS422_MODULE.uvprojx, settings and files
target RESS_MODULE (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RS422_MODULE +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\USER\INC;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\uCOSII\CORE;..\..\uCOSII\PORT;..\..\uCOSII\CONFIG
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../../USER/SRC/: main.c stm32f10x_it.c
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_tim.c
  group STM32_LIB
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c
  group MDK_STARTUP
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../USER/SRC/: system_stm32f10x.c
  group uC/OS-ⅡCORE
    ../../uCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uC/OS-ⅡPORT
    ../../uCOSII/PORT/: os_cpu_c.c os_dbg.c
